# Keil uVision project prj.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: prj +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Start;.\User;.\Library;.\Hardware;.\System
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s system_stm32f10x.h core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h
  group Library
    ./Library/: stm32f10x_crc.c stm32f10x_iwdg.c stm32f10x_dbgmcu.c stm32f10x_wwdg.c stm32f10x_exti.c misc.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_cec.c stm32f10x_dac.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_tim.c
  group System
    ./System/: Delay.h Delay.c
  group Hardware
    ./Hardware/: OLED.c OLED.h OLED_Font.h
  group User
    ./User/: main.c stm32f10x_it.h stm32f10x_conf.h stm32f10x_it.c
